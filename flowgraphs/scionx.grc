options:
  parameters:
    author: N6RFM
    generate_options: qt_gui
    id: scionx
    output_language: python
    title: scionx
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    start: '-15000'
    step: '100'
    stop: '15000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(freq-nfreq+offset)+BFO'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/bob/Desktop
    basefile: scionX
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'True'
    sampleRate: '50000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: 437.500e6
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4531'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: nfreq
  id: parameter
  parameters:
    label: Nominal Frequency
    type: eng_float
    value: 437.500e6
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=airspy,serial=466c64c8323184c7,soapy=0
    bb_gain0: '21'
    biast: 'False'
    freq0: nfreq-offset
    gain0: '21'
    gain_mode0: 'False'
    if_gain0: '21'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    name: SCIONX
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [low_pass_filter_0, '0', filerepeater_AdvFileSink_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
