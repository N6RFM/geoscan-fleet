options:
  parameters:
    author: N6RFM
    generate_options: qt_gui
    id: asrtussdv
    output_language: python
    title: asrtu_ssdv
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    start: '-15000'
    step: '100'
    stop: '15000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(freq-nfreq+offset)+BFO'
    offset: '0'
    phase: '0'
    samp_rate: '2500000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/bob/Desktop/
    basefile: ASRTU-1_beam_SSDV
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'True'
    sampleRate: '50000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: '436210000'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: 127.0.0.1
    gpredict_port: gpredict_port
    verbose: 'False'
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4531'
  states: {}
- name: lilacsat_attach_preamble_and_tailer_0
  id: lilacsat_attach_preamble_and_tailer
  parameters:
    comment: gr-lilacsat
    len_preamble: '0'
    len_tailer: '0'
    padding_type: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: To ASRTU SSDV Image Viewer :9985 (direct connection, no relay)
    host: 127.0.0.1
    mtu: '10000'
    port: '9985'
    type: TCP_SERVER
  states: {}
- name: nfreq
  id: parameter
  parameters:
    label: Nominal Frequency
    type: eng_float
    value: '436210000'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'SSDV '
  states: {}
- name: note_1
  id: note
  parameters:
    note: NOTE 4531
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: NOTE SSDV
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=airspy,serial=466c64c8323184c7,soapy=0
    bb_gain0: '20'
    biast: 'False'
    freq0: nfreq-offset
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_kiss_file_sink_0_0
  id: satellites_kiss_file_sink
  parameters:
    append: 'True'
    file: /home/bob/Desktop/ASRTU1_beam_SSDV.kss
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/bob/gr-satellites/python/satyaml/ASRTU-1.yml
    iq: 'True'
    norad: '49272'
    options: ''
    samp_rate: '50000'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    comment: Local Address to ssdv proxy  :5556
    timeout: '1000'
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [lilacsat_attach_preamble_and_tailer_0, out, network_socket_pdu_0, pdus]
- [lilacsat_attach_preamble_and_tailer_0, out, zeromq_pub_msg_sink_0, in]
- [low_pass_filter_0, '0', filerepeater_AdvFileSink_0, '0']
- [low_pass_filter_0, '0', satellites_satellite_decoder_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_1, '0']
- [satellites_print_timestamp_0, out, satellites_hexdump_sink_0, in]
- [satellites_satellite_decoder_0, out, lilacsat_attach_preamble_and_tailer_0, in]
- [satellites_satellite_decoder_0, out, satellites_kiss_file_sink_0_0, in]
- [satellites_satellite_decoder_0, out, satellites_print_timestamp_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
