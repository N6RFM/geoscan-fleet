options:
  parameters:
    author: N6RFM
    generate_options: qt_gui
    id: geoscan2
    output_language: python
    title: GEOSCAN-2
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    start: '-5000'
    step: '100'
    stop: '5000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(freq-nfreq+offset)+BFO'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/YOUR_USERNAME/Desktop
    basefile: geoscan2
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: 'True'
    sampleRate: '2500000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: '436163000'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: '''127.0.0.1'''
    mtu: '10000'
    port: '9102'
    tcp_no_delay: 'True'
    type: TCP_CLIENT
  states: {}
- name: nfreq
  id: parameter
  parameters:
    label: Nominal Frequency
    type: eng_float
    value: '436163000'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Doppler via shared rigctld on port 4532 (see rig_freq_poller_0)
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=airspy,serial=466c64c8323184c7,soapy=0
    bb_gain0: '20'
    biast: 'False'
    freq0: nfreq-offset
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '50000'
    fc: '0'
    fftsize: '1024'
    name: GEOSCAN-2
    type: complex
  states: {}
- name: rig_freq_poller_0
  id: epy_block
  parameters:
    _source_code: |
      import threading, time, socket
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, rig_host='127.0.0.1', rig_port=4532, poll_interval_s=0.5):
              gr.basic_block.__init__(self, name='rig_freq_poller', in_sig=None, out_sig=None)
              self.message_port_register_out(pmt.intern('freq'))
              self.rig_host = rig_host
              self.rig_port = rig_port
              self.poll_interval_s = poll_interval_s
              self._stop = threading.Event()
              self._thread = threading.Thread(target=self._loop, daemon=True)

          def start(self):
              self._thread.start()
              return True

          def stop(self):
              self._stop.set()
              return True

          def _loop(self):
              sock = None
              last = None
              while not self._stop.is_set():
                  try:
                      if sock is None:
                          sock = socket.create_connection((self.rig_host, self.rig_port), timeout=2)
                      sock.sendall(b'f\n')
                      freq = float(sock.recv(64).decode().strip())
                      if freq != last:
                          last = freq
                          self.message_port_pub(pmt.intern('freq'),
                                                 pmt.cons(pmt.intern('freq'), pmt.from_double(freq)))
                  except (OSError, ValueError):
                      sock = None
                  time.sleep(self.poll_interval_s)
    poll_interval_s: '0.5'
    rig_host: '''127.0.0.1'''
    rig_port: '4532'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    append: 'True'
    file: /home/YOUR_USERNAME/Desktop/GEOSCAN-2.kss
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/YOUR_USERNAME/Launches/current/GEOSCAN-2.yml
    iq: 'True'
    norad: '64890'
    options: ''
    samp_rate: '50000'
  states: {}
- name: satellites_telemetry_submit_0
  id: satellites_telemetry_submit
  parameters:
    norad: '64890'
    server: '"SatNOGS"'
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', filerepeater_AdvFileSink_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', satellites_satellite_decoder_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_1, '0']
- [rig_freq_poller_0, freq, gpredict_MsgPairToVar_0, inpair]
- [satellites_print_timestamp_0, out, satellites_hexdump_sink_0, in]
- [satellites_satellite_decoder_0, out, network_socket_pdu_0, pdus]
- [satellites_satellite_decoder_0, out, satellites_kiss_file_sink_0, in]
- [satellites_satellite_decoder_0, out, satellites_print_timestamp_0, in]
- [satellites_satellite_decoder_0, out, satellites_telemetry_submit_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
